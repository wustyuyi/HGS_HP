# Keil uVision project OpenRC.uvprojx, settings and files
target OpenRC (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: OpenRC +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD,ARM_MATH_CM3
  c include: .\Libraries\STM32F10x_StdPeriph_Driver\inc;.\Libraries\CMSIS\CM3\CoreSupport;.\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;.\Libraries\USB\Core;.\Libraries\USB\Config;.\Libraries\USB;.\User;.\Drivers;.\ZLG_GUI;.\APP_GUI
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Libraries/STM32F10x_StdPeriph_Driver
    ./Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group Libraries/CMSIS
    ./Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_hd.s
    ./Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: stm32f10x.h
    ./Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c core_cm3.h
  group Libraries/USB/Core
    ./Libraries/USB/Core/: usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c usb_sil.c
  group Libraries/USB/Config
    ./Libraries/USB/Config/: hw_config.c usb_desc.c usb_endp.c usb_istr.c usb_it.c usb_prop.c usb_pwr.c
    ./Libraries/USB/: Queue.c
  group User
    ./User/: main.c main.h stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h system_stm32f10x.c
  group Drivers
    ./Drivers/: delay.c OLED.c ADC.c RC.c key.c beep.c NRF24L01.c SPI2.c Bling.c Flight_Parameter_Table.c UART.c NCLink.c softiic.c softiic.h stflash.c stflash.h GPS.c PPM.c ppm.h
  group ZLG_GUI
    ./ZLG_GUI/: ConvertColor.c font5_7.c FONT8_8.C FONT24_32.C GUI_BASIC.C GUI_StockC.C lcmdrv.c loadbit.c menu.c spline.c windows.c CONFIG.h ConvertColor.h FONT_MACRO.H FONT5_7.H FONT8_8.H FONT24_32.H GUI_BASIC.H GUI_CONFIG.H GUI_StockC.h lcmdrv.h Loadbit.h menu.h spline.h WINDOWS.H
  group APP_GUI
    ./APP_GUI/: main_ui.c
